options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com
    description: This is a standalone test for the fosphor Qt widget. This widget is most often used in combination with the fosphor RFNoC block.
    generate_options: qt_gui
    id: test_fosphor_display
    output_language: python
    title: Fosphor Display Test
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Signal Amplitude
    start: '.1'
    step: '.05'
    stop: '1.0'
    value: '.7'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1.5e9
  states: {}
- name: pwr_bins
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e8)
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.9'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Format Data for histogram

      This block takes the data from an fft and collects and formats for the
      QT GUI Fosphor Display Block. This takes 64 samples, and organizes each
      sample into power bins across the frequency span in question. After this,
      the block sends those bins to the display block in 62 samples, the max levels
      in 1 vector, and the average level in 1 vector and tags the last vector.

      The last two vectors can be formatted to show whatever value the user would like
      rather than showing the average and maximum values.
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):

          def __init__(self, vec_length=256, bin_length=64, bin_size=2):  
              """arguments to this function show up as parameters in GRC"""
              self.index = 0
              # Amount of values in each frequency vector
              self.vec_length = vec_length
              # Amount of power bins to use
              self.bin_length = bin_length
              # How large each bin size is, for sorting samples
              self.bin_size = bin_size
              # Collect data over 64 vectors, then send out data while collecting next 64 vectors
              self.activeBin = 0
              self.bins = np.zeros(shape=(self.bin_length + 1, self.vec_length), dtype=np.ubyte)
              self.bins2 = np.zeros(shape=(self.bin_length + 1, self.vec_length), dtype=np.ubyte)
              self.average = np.zeros(vec_length)
              self.max = np.zeros(vec_length)
              gr.sync_block.__init__(
                  self,
                  name='Format data for histogram',
                  in_sig=[(np.float32, vec_length)],
                  out_sig=[(np.ubyte, vec_length)]
              )

          def update_vectors(self, array):
              """ 
              Take each vector, add to the weight of the bin vectors, and update max and
              average vectors as needed
              """
              for index in range(len(array)):
                  value = array[index] // self.bin_size
                  self.average[index] = self.average[index] + value / self.bin_length
                  if self.activeBin == 0:
                      for idx in range(min(value , self.bin_length - 1)):
                          self.bins[idx, index] = self.bins[idx, index] + 3
                  else:
                      for idx in range(min(value , self.bin_length - 1)):
                          self.bins2[idx, index] = self.bins2[idx, index] + 3
                  if value > self.max[index]:
                      self.max[index] = value

          def work(self, input_items, output_items):
              for index in range(len(input_items[0])):
                  self.update_vectors(input_items[0][index].astype(np.ubyte))
                  if self.index == self.bin_length + 1:
                      output_items[0][index] = 3 * self.max
                  elif self.index == self.bin_length + 2:
                      output_items[0][index] = 3 * self.average
                      self.average = np.zeros(self.vec_length)
                      self.max = np.zeros(self.vec_length)
                      key = pmt.intern('rx_eob')
                      value = pmt.intern('#t')
                      self.add_item_tag(0, self.nitems_written(0) + index, key, value)
                      self.index = 0
                      if self.activeBin == 0:
                          self.activeBin = 1
                          self.bins2 = np.zeros(shape=(self.bin_length + 1, self.vec_length), dtype=np.ubyte)
                      else:
                          self.activeBin = 0
                          self.bins = np.zeros(shape=(self.bin_length + 1, self.vec_length), dtype=np.ubyte)
                  else:
                      if self.activeBin == 0:
                          output_items[0][index] = self.bins2[self.index]
                      else:
                          output_items[0][index] = self.bins[self.index]
                  self.index = self.index + 1
              return len(output_items[0])
    bin_length: pwr_bins
    bin_size: '2'
    vec_length: fft_size
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Format Data for waterfall

      This block simply forwards the fft data vectors as 8-bit vector.
      The user can alter this to display a different result as desired.
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self, vec_size=256):
              gr.sync_block.__init__(
                  self,
                  name='Format data for Waterfall',
                  in_sig=[(np.single, vec_size)],
                  out_sig=[(np.ubyte, vec_size)]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0].astype(np.ubyte)
              return len(output_items[0])
    vec_size: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_fosphor_display_0
  id: qtgui_fosphor_display
  parameters:
    center_freq: freq
    fftsize: fft_size
    frame_rate: '30'
    grid_enabled: 'False'
    palette: iron
    pwr_bins: pwr_bins
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: 1024*4
    srate: '1'
    tr_delay: 1024*64
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_eob"'
    type: float
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_0, '0', qtgui_fosphor_display_0, '0']
- [epy_block_0_0, '0', qtgui_fosphor_display_0, '1']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-404-g7c433cd2
